# IAR project rpg_game_shell.ewp, settings and files
configuration rpg_game_shell (ARM, debug)
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa050,Pa084,Pa093,Pa082
  ICCARM.IExtraOptions: -DDEVICE_RTC=1; --enable_restrict; -DTOOLCHAIN_object; --guard_calls; -DDEVICE_SEMIHOST=1; -DFEATURE_LWIP=1; -DDEVICE_SLEEP=1; -DTARGET_LPC1768; -DTARGET_RELEASE; --diag_suppress=Pa050,Pa084,Pa093,Pa082; -DDEVICE_PORTINOUT=1; -e; -D__CORTEX_M3; -DDEVICE_DEBUG_AWARENESS=1; -DTARGET_M3; -DDEVICE_PWMOUT=1; -DDEVICE_CAN=1; -DDEVICE_PORTOUT=1; -DDEVICE_FLASH=1; -DDEVICE_STDIO_MESSAGES=1; -DDEVICE_ANALOGOUT=1; -DARM_MATH_CM3; -DDEVICE_INTERRUPTIN=1; -DTARGET_LIKE_CORTEX_M3; -DDEVICE_SERIAL=1; -DDEVICE_ANALOGIN=1; -DDEVICE_PORTIN=1; -DMBED_BUILD_TIMESTAMP=1524607517.77; -DTARGET_CORTEX_M; -DDEVICE_ETHERNET=1; -DDEVICE_I2C=1; --preinclude=mbed_config.h; -DTARGET_UVISOR_UNSUPPORTED; --no_wrap_diagnostics; -DTARGET_LPCTarget; -DTARGET_LIKE_MBED; -DDEVICE_SPI=1; -D__MBED__=1; -DTOOLCHAIN_IAR; -DDEVICE_SPISLAVE=1; -DDEVICE_SERIAL_FC=1; -DDEVICE_LOCALFILESYSTEM=1; -DTARGET_LPC176X; -DTARGET_CORTEX; -DDEVICE_I2CSLAVE=1; -D__CMSIS_RTOS; -DTARGET_NXP; -DTARGET_MBED_LPC1768; -D__MBED_CMSIS_RTOS_CM
  ICCARM.CCIncludePath2: .; SDFileSystem; SDFileSystem/FATFileSystem; SDFileSystem/FATFileSystem/ChaN; 4DGL-uLCD-SE; MMA8452; wave_player; mbed/.; mbed/TARGET_LPC1768; mbed/TARGET_LPC1768/TOOLCHAIN_IAR; 
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AExtraOptionsV2: -D__CMSIS_RTOS; -D__MBED_CMSIS_RTOS_CM; -D__CORTEX_M3; -DARM_MATH_CM3
  OBJCOPY.OOCOutputFile: name.srec
  ILINK.IlinkOutputFile: name.out
  ILINK.IlinkIcfFile: mbed/TARGET_LPC1768/TOOLCHAIN_IAR/LPC17xx.icf
  ILINK.IlinkExtraOptions: --skip_dynamic_initialization; --threaded_lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group rpg_game_shell
    ./: globals.h graphics.h hardware.h hash_table.h map.h speech.h graphics.cpp hardware.cpp hash_table.cpp main.cpp map.cpp speech.cpp
    /tmp/tmpqS31a3/: mbed_config.h
  group 4DGL-uLCD-SE
    4DGL-uLCD-SE/: uLCD_4DGL.h uLCD_4DGL_Graphics.cpp uLCD_4DGL_Media.cpp uLCD_4DGL_Text.cpp uLCD_4DGL_main.cpp
  group wave_player
    wave_player/: wave_player.h wave_player.cpp
  group SDFileSystem
    SDFileSystem/: SDFileSystem.h SDFileSystem.cpp
    SDFileSystem/FATFileSystem/: FATDirHandle.h FATFileHandle.h FATFileSystem.h FATDirHandle.cpp FATFileHandle.cpp FATFileSystem.cpp
    SDFileSystem/FATFileSystem/ChaN/: diskio.h ff.h ffconf.h integer.h ccsbcs.cpp diskio.cpp ff.cpp
  group MMA8452
    MMA8452/: MMA8452.h MMA8452.cpp
  group mbed
    mbed/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h CallChain.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FunctionPointer.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h SPI.h SPISlave.h Serial.h SerialBase.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h analogin_api.h analogout_api.h can_api.h can_helper.h error.h ethernet_api.h gpio_api.h gpio_irq_api.h i2c_api.h mbed.h mbed_debug.h mbed_interface.h pinmap.h platform.h port_api.h pwmout_api.h rtc_api.h rtc_time.h semihost_api.h serial_api.h sleep_api.h spi_api.h toolchain.h us_ticker_api.h wait_api.h
    mbed/TARGET_LPC1768/: LPC17xx.h PeripheralNames.h PinNames.h PortNames.h cmsis.h cmsis_nvic.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h device.h gpio_object.h objects.h system_LPC17xx.h
    mbed/TARGET_LPC1768/TOOLCHAIN_IAR/: cmsis_nvic.o retarget.o startup_LPC17xx.o system_LPC17xx.o mbed.a
